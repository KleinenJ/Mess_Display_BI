# IAR project EVK070016.ewp, settings and files
configuration EVK070016 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750XB ST STM32H750XB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H750xx; USE_USB_FS; USE_LWIP_DHCP=1; USE_BPP=16
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers\vendor\Board\SE21159\Config; ../Drivers\vendor\Driver; ../Drivers\vendor\DEVICE; ../TouchGFX/App; ../TouchGFX/target/generated; ../TouchGFX/target; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/ST/touchgfx/framework/include; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/texts/include; ../TouchGFX/generated/videos/include; ../TouchGFX/gui/include; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../ETHERNET_IF/App; ../ETHERNET_IF/App/tcpecho; ../ETHERNET_IF/App/udpecho; ../ETHERNET_IF/Target; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/LwIP/system/arch; ../ETHERNET_IF\App; ../ETHERNET_IF\Target; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../LWIP/App; ../LWIP/Target
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: EVK070016.hex
  ILINK.IlinkOutputFile: EVK070016.out
  ILINK.IlinkIcfFile: stm32h750xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h750xx.s
