# Keil uVision project EVK070016.uvprojx, settings and files
target EVK070016 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: EVK070016 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: ST,USE_HAL_DRIVER,STM32H750xx,USE_BPP=16,USE_USB_FS
  c misc: --diag_suppress 1300
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\EVK070016.sct
  link misc: --keep bootloader.o(bootloader_section)
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
    ./: bootloader.s
  group Lib
    ../Middlewares/ST/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
software components: CMSIS:CORE 4.3.0
